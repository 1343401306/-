# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F103xE
  c include: applications;.;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\rw007;packages\cJSON-latest;packages\cJSON-v1.7.14;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;packages\network_samples-latest;packages\network_samples-v0.3.0;packages\onenet-latest\inc;packages\pahomqtt-latest\MQTTPacket\src;packages\pahomqtt-latest\MQTTClient-RT;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\examples\utest\testcases\kernel;packages\webclient-latest\inc;packages\webclient-v2.1.2\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_client.c at_cli.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/rw007/: at_socket_rw007.c at_device_rw007.c
    packages/at_device-latest/samples/: at_sample_rw007.c
    packages/at_device-latest/src/: at_device.c
  group cJSON
    packages/cJSON-latest/: cJSON_Utils.c cJSON_port.c cJSON.c
    packages/cJSON-v1.7.14/: cJSON_Utils.c cJSON_port.c cJSON.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c waitqueue.c completion.c ringbuffer.c workqueue.c ringblk_buf.c pipe.c
  group Drivers
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: ipc.c kservice.c mempool.c memheap.c components.c timer.c object.c scheduler.c idle.c thread.c device.c irq.c mem.c clock.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c syscalls.c stdio.c mem_std.c
    ../../../components/libc/compilers/common/: stdlib.c time.c unistd.c delay.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group network-samples
    packages/network_samples-latest/: tcpclient_sample.c udpclient_sample.c
    packages/network_samples-v0.3.0/: tcpclient_sample.c udpclient_sample.c
  group onenet
    packages/onenet-latest/samples/: onenet_sample.c
    packages/onenet-latest/src/: onenet_http.c onenet_mqtt.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTConnectServer.c MQTTSubscribeClient.c MQTTUnsubscribeServer.c MQTTSubscribeServer.c MQTTPacket.c MQTTSerializePublish.c MQTTFormat.c MQTTUnsubscribeClient.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTSubscribeServer.c MQTTSerializePublish.c MQTTPacket.c MQTTUnsubscribeClient.c MQTTConnectClient.c MQTTSubscribeClient.c MQTTFormat.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group WebClient
    packages/webclient-latest/src/: webclient.c
    packages/webclient-v2.1.2/src/: webclient.c
